<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Xmas_Tree.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\Xmas_Tree_Branch\Xmas_Tree_Branch.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\Xmas_Tree_Test\Xmas_Tree_Test.ewp</path>
  </project>
  <batchBuild/>
</workspace>


